options:
  parameters:
    author: mzemlo.pl@gmail.com
    generate_options: qt_gui
    id: bpsk_01
    output_language: python
    title: BPSK 01
  states: {}

blocks:
- name: co
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    start: 70e3
    step: 1e6
    stop: 6e9
    value: 3.5e9
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: '65105'
    step: '1000'
    stop: '61440000'
    value: '10000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {state: disabled}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '2'
    minimum: '0'
    seed: '0'
    type: byte
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\mzeml\gnuradio\log\bpsk_003.log
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '100'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {state: disabled}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int ( sps )
    type: complex
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: ( -1  , 1 , 1 , 1 )
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int ( fc)
    samplerate: int ( samp_rate )
    type: fc32
    uri: usb:2.1.5
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int ( fc )
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int ( samp_rate )
    type: fc32
    uri: usb:2.1.5
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: Input
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: Output
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    name: '"input bits"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '2'
    min: '-2'
    name: output bits
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Input
    size: '1024'
    srate: int ( samp_rate )
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Output
    size: '1024'
    srate: int ( samp_rate )
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.95'
    decim: '1'
    gain: '1'
    ntaps: '1'
    samp_rate: int ( samp_rate )
    sym_rate: '1.0'
    type: fir_filter_ccf
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_random_uniform_source_x_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_threshold_ff_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_repeat_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_number_sink_1, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_const_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_keep_one_in_n_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0_0, '0']
- [root_raised_cosine_filter_0, '0', iio_pluto_sink_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
