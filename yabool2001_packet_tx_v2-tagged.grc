options:
  parameters:
    author: yabool2001
    copyright: mzemlo.pl@gmail.com
    description: packet tx v2 tagged
    generate_options: qt_gui
    id: yabool2001_packet_tx_v2_tagged
    output_language: python
    title: packet tx v2
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '820000000'
  states: {}
- name: my_constellation
  id: variable_constellation
  parameters:
    const_points: '[1, -1]'
    precision: '8'
    sym_map: '[0,1]'
    type: bpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '65105'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.make_u8vector ( 4 , 1 )
    period: '2000'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: digital.constellation_bpsk().base()
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/400.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: psf_taps
    type: ccf
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class pmt_to_stream(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="PMT 2 STREAM",
                  in_sig=None,
                  out_sig=[np.byte])  # Wyjście jako strumień bajtów
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              # Przekształć wiadomość (PMT) na bajty
              self.message = pmt.to_python(msg)
              if pmt.is_u8vector(msg):
                  self.message = bytearray(pmt.u8vector_elements(msg))
              if isinstance(self.message, str):
                  self.message = bytearray(self.message, 'utf-8')
              elif isinstance(self.message, bytes):
                  self.message = bytearray(self.message)
              else:
                  self.message = bytearray()

          def work(self, input_items, output_items):
              if hasattr(self, 'message') and self.message:
                  # Skopiuj dane do wyjścia
                  output_items[0][:len(self.message)] = self.message
                  self.message = bytearray()  # Wyczyść wiadomość po wysłaniu
                  return len(output_items[0])
              return 0
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    label2: ''
    legend: 'False'
    size: '1024'
    srate: samp_rate
    tr_tag: packet_len
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_message_strobe_0, strobe, epy_block_0, in]
- [blocks_stream_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0, '0', blocks_stream_to_tagged_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
