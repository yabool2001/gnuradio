options:
  parameters:
    author: yabool2001
    copyright: mzemlo.pl@gmail.com
    description: QPSK modulation nice visualisation with Pluto
    generate_options: qt_gui
    id: yabool2001_QPSK_mod_nice_visual_w_Pluto
    output_language: python
    title: QPSK modulation nice visualisation with Pluto
  states: {}

blocks:
- name: Pluto_iio_context_uri_ip
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: f_c
  id: variable
  parameters:
    value: '2000000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_Pluto
  id: variable
  parameters:
    value: 65105*8
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: bw
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: f_c
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate_Pluto
    type: fc32
    uri: Pluto_iio_context_uri_ip
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: bw*10
    fc: f_c
    fftsize: '1024'
    name: '"FFT"'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
