options:
  parameters:
    author: yabool2001
    copyright: maciej.zemlo@gmail.pl
    generate_options: qt_gui
    id: tuto_chatgpt_FM_receiver
    output_language: python
    title: ChatGPT FM receiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: f_cutoff
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: f_radio
  id: variable
  parameters:
    value: 103*10**6
  states: {}
- name: hw_uri
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: trans_width
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: samp_rate/decimation
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: audio_rate*4
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: default
    samp_rate: audio_rate
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: f_radio
    samplerate: samp_rate
    type: fc32
    uri: usb:3.15.5
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: f_radio
    gain1: '''fast_attack'''
    manual_gain1: '40'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: hw_uri
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_cutoff
    decim: decimation
    gain: '1'
    samp_rate: samp_rate/decimation
    type: fir_filter_ccf
    width: trans_width
    win: window.WIN_HAMMING
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_tx_0, '0', iio_pluto_sink_0, '0']
- [audio_source_0, '0', analog_wfm_tx_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
