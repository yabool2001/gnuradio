options:
  parameters:
    author: yabool2001
    copyright: maciej.zemlo@gmail.pl
    generate_options: qt_gui
    id: tuto_chatgpt_FM_receiver
    output_language: python
    title: ChatGPT FM receiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: f_cutoff
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: f_radio
  id: variable
  parameters:
    value: '103000000'
  states: {}
- name: hw_uri
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: trans_width
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    label: Pluto Tx Attenuation
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: samp_rate/decimation
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: audio_rate*4
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: Mikrofon (HD Pro Webcam C910)
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\mzeml\gnuradio\FM tutos\15.Variation_14.wav
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: f_radio
    samplerate: audio_rate*4
    type: fc32
    uri: hw_uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: f_radio
    gain1: '''fast_attack'''
    manual_gain1: '40'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: hw_uri
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_cutoff
    decim: decimation
    gain: '1'
    samp_rate: samp_rate/decimation
    type: fir_filter_ccf
    width: trans_width
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: f_radio
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_tx_0, '0', iio_pluto_sink_0, '0']
- [audio_source_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
