options:
  parameters:
    author: yabool2001
    copyright: mzemlo.pl@gmail.com
    description: QPSK demonstration over ADALM-Pluto
    generate_options: qt_gui
    id: Moazzam_Q38_QPSK_test_01
    output_language: python
    title: Moazzam 38. QPSK test 01
  states: {}

blocks:
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.init_u8vector ( 4 , [ 0x01 , 0x02 , 0x03 , 0x04 ] )
    period: '1000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: ( 0 , 1 , 1 , 0 )
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: float
  states: {}

connections:
- [blocks_message_strobe_1, strobe, blocks_message_debug_0, print]
- [blocks_message_strobe_1, strobe, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
