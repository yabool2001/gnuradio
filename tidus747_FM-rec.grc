options:
  parameters:
    author: Iván Rodríguez
    copyright: '2021'
    description: FM Receiver
    generate_options: qt_gui
    id: FM_Receiver
    output_language: python
    title: FM Receiver
  states: {}

blocks:
- name: audio_dec
  id: variable
  parameters:
    value: '10'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: frec
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '105600000'
    step: '100000'
    stop: '108000000'
    value: '105600000'
  states: {}
- name: quadrature
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: Squelch Level
    start: '-100'
    step: '1'
    stop: '0'
    value: '-50'
  states: {}
- name: transition
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '0.25'
    stop: '10'
    value: '1'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_dec
    quad_rate: quadrature
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: frec
    gain1: '''slow_attack'''
    quadrature: 'False'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: '"ip:192.168.2.1"'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"usb:3.15.5"'
    bb_gain0: '20'
    freq0: frec
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    name: Demodulated Signal WB
    size: '4096'
    srate: samp_rate
    type: float
    update_time: '0.01'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: RF Signal
    size: '4096'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    label1: Central Frec
    name: Spectrogram
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '50'
    interp: '48'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', analog_wfm_rcv_0, '0']
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_1, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_1, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
