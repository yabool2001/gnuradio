options:
  parameters:
    author: yabool2001
    copyright: maciej.zemlo@gmail.com
    generate_options: qt_gui
    id: constellation_test
    output_language: python
    title: constellation test
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: frequency center
    start: '1'
    step: '1'
    stop: '2'
    value: '1'
  states: {}
- name: P
  id: variable_qtgui_range
  parameters:
    label: frequency center
    start: '0'
    step: '90'
    stop: '270'
    value: '0'
  states: {}
- name: f_c
  id: variable_qtgui_range
  parameters:
    label: frequency center
    start: '0'
    step: '10'
    stop: '100000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: f_c*4
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: f_c
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_c
    offset: P
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f_c
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_1_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 0,1,1,1
    name: '"Complex signal"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Real signal"'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0, '0', blocks_float_to_complex_0, '0']
- [blocks_throttle2_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_throttle2_0_1, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_throttle2_0_1_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
