options:
  parameters:
    author: yabool2001
    comment: Stable version
    copyright: mzemlo.pl@gmail.com
    generate_options: qt_gui
    id: Tagged_Stream_sb_01
    output_language: python
    title: Tagged Stream sandbox 01
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_1_0
  id: blocks_message_strobe
  parameters:
    comment: |-
      HEX: 0x13
      BIN: 0b00010011
      DEC: 19
    msg: pmt.cons ( pmt.PMT_NIL , pmt.make_u8vector ( 5 , 0x13 ) )
    period: '1000'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: PDU to Tagged Stream
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [blocks_message_strobe_1_0, strobe, pdu_pdu_to_tagged_stream_0, pdus]
- [blocks_throttle2_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tag_debug_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
