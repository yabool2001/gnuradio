options:
  parameters:
    author: yabool2001
    comment: |-
      https://wiki.gnuradio.org/index.php/Packet_Communications
      Stable version
    copyright: mzemlo.pl@gmail.com
    generate_options: qt_gui
    id: CRC_Check_sb_02
    output_language: python
    title: CRC Check sandbox 02
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    comment: |-
      HEX: 0x31
      BIN: 0b00110001
      DEC: 49
      ASCII: 1
    msg: pmt.cons ( pmt.PMT_NIL , pmt.make_u8vector ( 1 , 0x31 ) )
    period: '1000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: epy_block_1_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class byte_logger(gr.sync_block):
          def __init__(self, samp_rate=32000, filename="byte_log.csv"):
              gr.sync_block.__init__(self,
                  name="BYTE FILE SINK",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.start_time = time.time()

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;byte;samp_rate\n")

          def work(self, input_items, output_items):
              current_time = time.time()
              elapsed = current_time - self.start_time

              for i, b in enumerate(input_items[0]):
                  timestamp = elapsed + (i / self.samp_rate)
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  val = str(b)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')
                  self.f.write(f"{ts};{val};{sr}\n")

              self.f.flush()
              return len(input_items[0])
    filename: '"01_byte_rx_log.csv"'
    samp_rate: samp_rate
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [blocks_message_strobe_1, strobe, digital_crc_append_0, in]
- [blocks_throttle2_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_crc_append_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_crc_check_0, ok, blocks_message_debug_0, print]
- [digital_crc_check_0, ok, pdu_pdu_to_tagged_stream_0_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_throttle2_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', epy_block_1_0_0_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, digital_crc_check_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
