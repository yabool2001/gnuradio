options:
  parameters:
    author: mzemlo.pl@gmail.com
    generate_options: qt_gui
    id: bpsk_01
    output_language: python
    title: BPSK 01
  states: {}

blocks:
- name: datarate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: f
  id: variable
  parameters:
    value: 3.5e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '65105'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (1+0j, -1+0j, 1+0j)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(f)
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(f)
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: (0, 0, 1, 1)
    name: output constellation sink
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: (1, 0, 1, 3)
    name: input constellation sink
    size: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: (0, 1, 1, 1)
    min: '0'
    name: '"output bits"'
    type: float
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: (0, 2, 1, 1)
    min: '0'
    name: '"output bits"'
    type: float
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_number_sink_1, '0']
- [blocks_complex_to_float_0, '1', qtgui_number_sink_1_0, '0']
- [blocks_vector_source_x_0, '0', iio_pluto_sink_0, '0']
- [blocks_vector_source_x_0, '0', qtgui_const_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_float_0, '0']
- [iio_pluto_source_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
