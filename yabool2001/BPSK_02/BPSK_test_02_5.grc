options:
  parameters:
    author: yabool2001
    comment: |-
      https://wiki.gnuradio.org/index.php/Packet_Communications
      Stable
    copyright: mzemlo.pl@gmail.com
    generate_options: qt_gui
    id: BPSK_test_02_5
    output_language: python
    title: BPSK test 02.5
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    comment: |-
      HEX: F0 F0 AA AA
      DEC: 240 240 170 170
    value: '''11110000111100001010101010101010'''
  states: {}
- name: f_c
  id: variable
  parameters:
    value: '820000000'
  states: {}
- name: header
  id: variable
  parameters:
    value: digital.header_format_default ( access_key , 0 )
  states: {}
- name: my_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '65105'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1e-4'
    threshold: '-60'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    comment: |-
      HEX: 0x13
      BIN: 0b00010011
      DEC: 19
    msg: pmt.cons ( pmt.PMT_NIL , pmt.make_u8vector ( 1 , 0x13 ) )
    period: '1000'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: Append header to payload
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: my_constellation
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: my_constellation
    differential: 'False'
    excess_bw: '0.35'
    log: 'True'
    samples_per_symbol: sps
    verbose: 'True'
  states: {}
- name: digital_correlate_access_code_xx_ts_1_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    comment: Correlates with access code to extract the payload.
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_1_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    comment: Correlates with access code to extract the payload.
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: header
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class byte_logger(gr.sync_block):
          def __init__(self, samp_rate=32000, filename="byte_log.csv"):
              gr.sync_block.__init__(self,
                  name="BYTE FILE SINK",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.start_time = time.time()

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;byte;samp_rate\n")

          def work(self, input_items, output_items):
              current_time = time.time()
              elapsed = current_time - self.start_time

              for i, b in enumerate(input_items[0]):
                  timestamp = elapsed + (i / self.samp_rate)
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  val = str(b)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')
                  self.f.write(f"{ts};{val};{sr}\n")

              self.f.flush()
              return len(input_items[0])
    filename: '"01_byte_tx_log.csv"'
    samp_rate: samp_rate
  states: {state: disabled}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class byte_logger(gr.sync_block):
          def __init__(self, samp_rate=32000, filename="byte_log.csv"):
              gr.sync_block.__init__(self,
                  name="BYTE FILE SINK",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.start_time = time.time()

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;byte;samp_rate\n")

          def work(self, input_items, output_items):
              current_time = time.time()
              elapsed = current_time - self.start_time

              for i, b in enumerate(input_items[0]):
                  timestamp = elapsed + (i / self.samp_rate)
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  val = str(b)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')
                  self.f.write(f"{ts};{val};{sr}\n")

              self.f.flush()
              return len(input_items[0])
    filename: '"02_byte_tx_log.csv"'
    samp_rate: samp_rate
  states: {}
- name: epy_block_1_0_1
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class byte_logger(gr.sync_block):
          def __init__(self, samp_rate=32000, filename="byte_log.csv"):
              gr.sync_block.__init__(self,
                  name="BYTE FILE SINK",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.start_time = time.time()

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;byte;samp_rate\n")

          def work(self, input_items, output_items):
              current_time = time.time()
              elapsed = current_time - self.start_time

              for i, b in enumerate(input_items[0]):
                  timestamp = elapsed + (i / self.samp_rate)
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  val = str(b)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')
                  self.f.write(f"{ts};{val};{sr}\n")

              self.f.flush()
              return len(input_items[0])
    filename: '"03_byte_rx_log.csv"'
    samp_rate: samp_rate
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '1'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: f_c
    samplerate: samp_rate
    type: fc32
    uri: 'usb:'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: f_c
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 'usb:'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: Wymaga wcześniejszego "Stream to Tagged Stream".
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: Wymaga wcześniejszego "Stream to Tagged Stream".
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: f_c
    fftsize: '1024'
    name: '"Rx"'
    type: complex
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_sink_x_0, '0']
- [blocks_message_strobe_1, strobe, pdu_pdu_to_tagged_stream_0, pdus]
- [blocks_pack_k_bits_bb_0_0, '0', epy_block_1_0_1, '0']
- [blocks_pack_k_bits_bb_0_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_pack_k_bits_bb_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_1_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_xx_ts_1_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_correlate_access_code_xx_ts_1_0_0, '0']
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [digital_correlate_access_code_xx_ts_1_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_correlate_access_code_xx_ts_1_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_protocol_formatter_bb_0, '0', epy_block_1_0_0, '0']
- [iio_pluto_source_0, '0', analog_simple_squelch_cc_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print]
- [pdu_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
