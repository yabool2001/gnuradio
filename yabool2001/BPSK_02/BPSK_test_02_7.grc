options:
  parameters:
    author: yabool2001
    comment: |-
      https://wiki.gnuradio.org/index.php/Packet_Communications
      Stable
    copyright: mzemlo.pl@gmail.com
    generate_options: qt_gui
    id: BPSK_test_02_4
    output_language: python
    title: BPSK test 02.4
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    comment: |-
      HEX: F0 F0 F0 AA AA AA
      DEC: 240 240 240 170 170 170
    value: '''111100001111000011110000101010101010101010101010'''
  states: {}
- name: access_key_0
  id: variable
  parameters:
    comment: |-
      HEX: F0 F0 F0 AA AA AA
      DEC: 240 240 240 170 170 170
    value: '''101010101010101010101010'''
  states: {}
- name: bw
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: f_c
  id: variable
  parameters:
    value: '2900000000'
  states: {}
- name: header
  id: variable
  parameters:
    comment: |-
      digital.header_format_default
      ( access_key , 0 )
    value: digital.header_format_default ( access_key , 0 )
  states: {}
- name: my_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '65105'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    comment: firdes.root_raised_cosine ( nfilts , nfilts , 1.0 / float ( sps ) , 0.35 , 11 * sps * nfilts )
    value: firdes.root_raised_cosine ( nfilts , nfilts , 1.0 / float ( sps ) , 0.35 , 11 * sps * nfilts )
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '49'
    type: byte
  states: {state: disabled}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1e-4'
    threshold: '-40'
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    comment: |-
      HEX: 0x31
      BIN: 0b00110001
      DEC: 49
      ASCII: 1
    msg: pmt.cons ( pmt.PMT_NIL , pmt.make_u8vector ( 1 , 0x31 ) )
    period: '1000'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '8'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: Append header to payload
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: my_constellation
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: my_constellation
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
    verbose: 'True'
  states: {}
- name: digital_correlate_access_code_xx_ts_1_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    comment: access_key
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc_append_0
  id: digital_crc_append
  parameters:
    poly: '0x4C11DB7'
  states: {}
- name: digital_crc_check_0
  id: digital_crc_check
  parameters:
    comment: Discard CRC = True
    discard_crc: 'True'
    poly: '0x4C11DB7'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: taps
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    comment: header
    format: header
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class complex_sps_file_sink(gr.sync_block):
          def __init__(self, samp_rate=32000, sps=2, filename="complex_log.csv"):
              gr.sync_block.__init__(self,
                  name="Complex Sps File Sink",
                  in_sig=[np.complex64],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.sps = sps
              self.start_time = time.time()
              self.sample_index = 0  # licznik próbek

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;real;imag;symbol_index;samp_rate\n")

          def work(self, input_items, output_items):
              elapsed = time.time() - self.start_time
              for c in input_items[0]:
                  timestamp = elapsed
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  re = f"{c.real:.6f}".replace('.', ',')
                  im = f"{c.imag:.6f}".replace('.', ',')
                  symbol_idx = str(self.sample_index // self.sps)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')

                  self.f.write(f"{ts};{re};{im};{symbol_idx};{sr}\n")

                  elapsed += 1 / self.samp_rate
                  self.sample_index += 1

              self.f.flush()
              return len(input_items[0])
    filename: '"03_complex_tx_bpsk_mod_log.csv"'
    samp_rate: samp_rate
    sps: sps
  states: {state: disabled}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class byte_logger(gr.sync_block):
          def __init__(self, samp_rate=32000, filename="byte_log.csv"):
              gr.sync_block.__init__(self,
                  name="BYTE FILE SINK",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.start_time = time.time()

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;byte;samp_rate\n")

          def work(self, input_items, output_items):
              current_time = time.time()
              elapsed = current_time - self.start_time

              for i, b in enumerate(input_items[0]):
                  timestamp = elapsed + (i / self.samp_rate)
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  val = str(b)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')
                  self.f.write(f"{ts};{val};{sr}\n")

              self.f.flush()
              return len(input_items[0])
    filename: '"02_byte_tx_log.csv"'
    samp_rate: samp_rate
  states: {}
- name: epy_block_1_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class byte_logger(gr.sync_block):
          def __init__(self, samp_rate=32000, filename="byte_log.csv"):
              gr.sync_block.__init__(self,
                  name="BYTE FILE SINK",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.start_time = time.time()

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;byte;samp_rate\n")

          def work(self, input_items, output_items):
              current_time = time.time()
              elapsed = current_time - self.start_time

              for i, b in enumerate(input_items[0]):
                  timestamp = elapsed + (i / self.samp_rate)
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  val = str(b)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')
                  self.f.write(f"{ts};{val};{sr}\n")

              self.f.flush()
              return len(input_items[0])
    filename: '"06_byte_rx_log.csv"'
    samp_rate: samp_rate
  states: {}
- name: epy_block_1_0_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class byte_logger(gr.sync_block):
          def __init__(self, samp_rate=32000, filename="byte_log.csv"):
              gr.sync_block.__init__(self,
                  name="BYTE FILE SINK",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.start_time = time.time()

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;byte;samp_rate\n")

          def work(self, input_items, output_items):
              current_time = time.time()
              elapsed = current_time - self.start_time

              for i, b in enumerate(input_items[0]):
                  timestamp = elapsed + (i / self.samp_rate)
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  val = str(b)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')
                  self.f.write(f"{ts};{val};{sr}\n")

              self.f.flush()
              return len(input_items[0])
    filename: '"01_byte_tx_log.csv"'
    samp_rate: samp_rate
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '6'
    bandwidth: bw
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: f_c
    samplerate: samp_rate
    type: fc32
    uri: 'usb:'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: bw
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: f_c
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 'usb:'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xFF'
    maxsize: '4'
    minsize: '4'
  states: {}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: Wymaga wcześniejszego "Stream to Tagged Stream".
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: '40000000'
    fc: f_c
    fftsize: '1024'
    name: '"Rx"'
    plotwaterfall: 'False'
    showports: 'True'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [analog_simple_squelch_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_sink_x_0, '0']
- [blocks_message_strobe_1, strobe, pdu_random_pdu_0, generate]
- [blocks_pack_k_bits_bb_0_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_tagged_stream_mux_0, '0', epy_block_1_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_correlate_access_code_xx_ts_1_0_0, '0']
- [digital_constellation_modulator_0, '0', epy_block_0_0, '0']
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [digital_correlate_access_code_xx_ts_1_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [digital_crc_append_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [digital_crc_check_0, ok, blocks_message_debug_0_0, print]
- [digital_crc_check_0, ok, pdu_pdu_to_tagged_stream_0_0, pdus]
- [digital_pfb_clock_sync_xxx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [iio_pluto_source_0, '0', analog_simple_squelch_cc_0, '0']
- [iio_pluto_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', epy_block_1_0_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0_0_0, '0', epy_block_1_0_0_0_1, '0']
- [pdu_random_pdu_0, pdus, digital_crc_append_0, in]
- [pdu_random_pdu_0, pdus, pdu_pdu_to_tagged_stream_0_0_0, pdus]
- [pdu_tagged_stream_to_pdu_0_0, pdus, digital_crc_check_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
