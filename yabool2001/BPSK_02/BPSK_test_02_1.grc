options:
  parameters:
    author: yabool2001
    copyright: mzemlo.pl@gmail.com
    description: BPSK test 02
    generate_options: qt_gui
    id: BPSK_test_02_1
    output_language: python
    title: BPSK test 02
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: f_c
  id: variable
  parameters:
    value: '820000000'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pluto_context
  id: variable
  parameters:
    value: '"usb:"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(bw*3)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: variable_constellation_1
  id: variable_constellation
  parameters:
    const_points: '[1, -1]'
    precision: '8'
    sym_map: '[0,1]'
    type: bpsk
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: output_text.txt
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\mzeml\gnuradio\udemy Moazzam\tagged_stream.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\mzeml\gnuradio\udemy Moazzam\input_text.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    comment: |-
      HEX: 0x11
      BIN: 0b00010001
      DEC: 17
    msg: |
      pmt.cons(pmt.PMT_NIL, pmt.init_u8vector(8, [0x11, 0x22, 0x33, 0x44, 0x55, 0x66, 0x77, 0x88]))
    period: '500'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Tagged Stream to PDU block up ahead needs packed bytes
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '24'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: Append header to payload
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_1_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_1
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_1
    differential: 'False'
    excess_bw: '0.35'
    log: 'True'
    samples_per_symbol: '4'
    verbose: 'True'
  states: {}
- name: digital_correlate_access_code_xx_ts_1
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: Correlates with access code to extract the payload.
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    sps: '4'
    taps: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    comment: Generate header
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '1'
    bandwidth: bw
    buffer_size: int(samp_rate/24)
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: f_c
    samplerate: samp_rate
    type: fc32
    uri: pluto_context
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: bw
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: f_c
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto_context
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '20'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: f_c
    fftsize: '1024'
    type: complex
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_message_strobe_1, strobe, pdu_pdu_to_tagged_stream_0, pdus]
- [blocks_repack_bits_bb_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0_0, '0']
- [digital_constellation_decoder_cb_1_0, '0', blocks_file_sink_0_0_0_0, '0']
- [digital_constellation_decoder_cb_1_0, '0', digital_correlate_access_code_xx_ts_1, '0']
- [digital_constellation_modulator_0_0, '0', iio_pluto_sink_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_correlate_access_code_xx_ts_1, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_constellation_decoder_cb_1_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_1, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [iio_pluto_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
