options:
  parameters:
    author: yabool2001
    copyright: mzemlo.pl@gmail.com
    description: BPSK test 02 3
    generate_options: qt_gui
    id: BPSK_test_02_1_1
    output_language: python
    title: BPSK test 02 3
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: bw2
  id: variable_qtgui_range
  parameters:
    label: bw2
    rangeType: int
    start: '1000000'
    step: '1000000'
    stop: '50000000'
    value: '1000000'
  states: {}
- name: f_c
  id: variable
  parameters:
    value: '2900000000'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pluto_context
  id: variable
  parameters:
    value: '"usb:"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(bw*3)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_constellation_1
  id: variable_constellation
  parameters:
    const_points: '[1, -1]'
    precision: '8'
    sym_map: '[0,1]'
    type: bpsk
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0x0A'
    type: byte
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_1
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: bw2
    buffer_size: int(samp_rate/24)
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: f_c
    samplerate: samp_rate
    type: fc32
    uri: pluto_context
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: bw2
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: f_c
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: pluto_context
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Rx"'
    size: '137'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Tx"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [analog_const_source_x_0, '0', digital_constellation_modulator_0_0, '0']
- [digital_constellation_modulator_0_0, '0', iio_pluto_sink_0, '0']
- [digital_constellation_modulator_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
