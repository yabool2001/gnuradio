options:
  parameters:
    author: yabool2001
    comment: |-
      https://wiki.gnuradio.org/index.php/Packet_Communications
      Stable
    copyright: mzemlo.pl@gmail.com
    generate_options: qt_gui
    id: bpsk_modulator_00_1_const
    output_language: python
    title: bpsk modulator v 00.1-const
  states: {}

blocks:
- name: att_range
  id: variable_qtgui_range
  parameters:
    label: Attenuation
    rangeType: int
    start: '10'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: f_c
  id: variable
  parameters:
    value: '2900000000'
  states: {}
- name: my_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '521100'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0x0A'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: my_constellation
    differential: 'False'
    excess_bw: '0.35'
    log: 'True'
    samples_per_symbol: sps
    verbose: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '30'
    bandwidth: bw
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: f_c
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: f_c
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [analog_const_source_x_0, '0', digital_constellation_modulator_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
