options:
  parameters:
    author: yabool2001
    copyright: mzemlo.pl@gmail.com
    generate_options: qt_gui
    id: bpsk_modulator_00_1_const
    output_language: python
    title: bpsk modulator v 00.1-const
  states: {}

blocks:
- name: att_range
  id: variable_qtgui_range
  parameters:
    label: Attenuation
    start: '1.0'
    step: '1'
    stop: '70.0'
    value: '1.2'
  states: {}
- name: bw
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: ctx_ip
  id: variable
  parameters:
    value: '"ip:192.168.2.1"'
  states: {}
- name: ctx_usb
  id: variable
  parameters:
    value: '"usb:"'
  states: {}
- name: f_c
  id: variable
  parameters:
    value: '2900000000'
  states: {}
- name: my_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0.1'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '521100'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0x0F'
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: my_constellation
    differential: 'False'
    excess_bw: '0.35'
    log: 'True'
    samples_per_symbol: sps
    verbose: 'True'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class complex_sps_file_sink(gr.sync_block):
          def __init__(self, samp_rate=32000, sps=2, filename="complex_log.csv"):
              gr.sync_block.__init__(self,
                  name="Complex Sps File Sink",
                  in_sig=[np.complex64],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.sps = sps
              self.start_time = time.time()
              self.sample_index = 0  # licznik próbek

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;real;imag;symbol_index;samp_rate\n")

          def work(self, input_items, output_items):
              elapsed = time.time() - self.start_time
              for c in input_items[0]:
                  timestamp = elapsed
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  re = f"{c.real:.6f}".replace('.', ',')
                  im = f"{c.imag:.6f}".replace('.', ',')
                  symbol_idx = str(self.sample_index // self.sps)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')

                  self.f.write(f"{ts};{re};{im};{symbol_idx};{sr}\n")

                  elapsed += 1 / self.samp_rate
                  self.sample_index += 1

              self.f.flush()
              return len(input_items[0])
    filename: '"01_complex_tx_bpsk_mod_log.csv"'
    samp_rate: samp_rate
    sps: sps
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class complex_sps_file_sink(gr.sync_block):
          def __init__(self, samp_rate=32000, sps=2, filename="complex_log.csv"):
              gr.sync_block.__init__(self,
                  name="Complex Sps File Sink",
                  in_sig=[np.complex64],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.sps = sps
              self.start_time = time.time()
              self.sample_index = 0  # licznik próbek

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;real;imag;symbol_index;samp_rate\n")

          def work(self, input_items, output_items):
              elapsed = time.time() - self.start_time
              for c in input_items[0]:
                  timestamp = elapsed
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  re = f"{c.real:.6f}".replace('.', ',')
                  im = f"{c.imag:.6f}".replace('.', ',')
                  symbol_idx = str(self.sample_index // self.sps)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')

                  self.f.write(f"{ts};{re};{im};{symbol_idx};{sr}\n")

                  elapsed += 1 / self.samp_rate
                  self.sample_index += 1

              self.f.flush()
              return len(input_items[0])
    filename: '"02_complex_rx_bpsk_mod_log.csv"'
    samp_rate: samp_rate
    sps: sps
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: att_range
    bandwidth: bw
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: f_c
    samplerate: samp_rate
    type: fc32
    uri: ctx_ip
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: bw
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: f_c
    gain1: '''manual'''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ctx_usb
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Constellation Modulator"'
    size: '1'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Pluto Source"'
    size: '1'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: f_c
    fftsize: '1024'
    name: '"Constellation Modulator"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: f_c
    fftsize: '1024'
    name: '"Pluto Source"'
    type: complex
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', epy_block_0_0, '0']
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', epy_block_0_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_const_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
