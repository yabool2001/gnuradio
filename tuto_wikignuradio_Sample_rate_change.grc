options:
  parameters:
    author: yabool2001
    copyright: maciej.zemlo@gmail.pl
    description: https://wiki.gnuradio.org/index.php?title=Sample_Rate_Change
    generate_options: qt_gui
    id: tuto_wikignuradio_Sample_rate_change
    output_language: python
    title: Wiki Tuto GNU Radio Sample rate change Example
  states: {}

blocks:
- name: f
  id: variable_qtgui_range
  parameters:
    label: frequency
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: f_cutoff
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '1000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: n
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: trans_width
  id: variable
  parameters:
    value: '200'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: f
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_filter_taps
    type: ccc
  states: {state: disabled}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
