options:
  parameters:
    author: Maciej Zemlo
    comment: |-
      https://www.youtube.com/watch?v=ODU-PvH1_Hg
      https://www.youtube.com/watch?v=PJnSFtk_pl4
      https://github.com/gallicchio/learnSDR/blob/main/lesson08a_plutoTXRX.grc
      https://github.com/gallicchio/learnSDR/blob/main/lesson11_ASK_Pluto_to_RTL_SDR.grc

      Modification:
      ASK implementation 11 on the base of Pluto 2 Pluto 08a example
    copyright: mzemlo.pl@gmail.com
    generate_options: qt_gui
    id: lesson_mix_08a_11
    output_language: python
    title: lesson_mix_08a_11
  states: {}

blocks:
- name: fc
  id: variable_qtgui_range
  parameters:
    start: 868e6
    step: '1000000'
    stop: 870e6
    value: 869e6
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sampling rate
    start: '65105'
    step: '10000'
    stop: '61440000'
    value: '65105'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    start: '10'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int ( sps )
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int ( sps )
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: ( 1/2 , 1 )
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int ( fc )
    samplerate: int (samp_rate )
    type: fc32
    uri: usb:2.10.5
  states: {}
- name: iio_pluto_sink_1
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int ( fc )
    samplerate: int ( samp_rate )
    type: fc32
    uri: 192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int ( fc )
    gain1: '''slow_attack'''
    manual_gain1: '0'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int ( samp_rate )
    type: fc32
    uri: usb:2.10.5
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: Input constellation
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: Output constellation
    size: 1024*8
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: int ( fc )
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Output Mag"'
    size: 1024*8
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Output Mag"'
    size: 1024*8
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_repeat_0, '0', iio_pluto_sink_0, '0']
- [blocks_repeat_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_0, '0']
- [iio_pluto_source_0, '0', qtgui_const_sink_x_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
