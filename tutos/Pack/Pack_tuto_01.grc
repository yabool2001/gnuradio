options:
  parameters:
    author: yabool2001
    copyright: mzemlo.pl@gmail.com
    description: Pack tuto 01
    generate_options: qt_gui
    id: Pack_tuto_01
    output_language: python
    title: Pack tuto 01
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    comment: |-
      HEX: 0xAE
      DEC: 174
      BIN: 0b10101110
    msg: pmt.cons ( pmt.PMT_NIL , pmt.make_u8vector ( 1 , 0xAE ) )
    period: '1000'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    comment: |-
      When receiving 8 bytes
      at the input
      in the following time order:  
      0b00000001,  
      0b00000000,  
      0b00000001,  
      0b00000000,  
      0b00000001,  
      0b00000001,  
      0b00000001,  
      0b00000000,  

      it will process them
      as MSB endianness
      and output a single byte:
      `0b10101110`.
    k: '8'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      For single-byte streams, select "Input" for the "Packet Alignment" parameter.
      In the case of a previously used "Pack K Bits" block, choose "MSB" endianness.
      Setting it to "LSB" results in 117 (`0b01110101`) instead of 174 (`0b10101110`).
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: |-
      For "Packet Alignment" set to
      Input and MSB andianness,
      it works the same as
      "Pack K Bits" with K=8.
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    comment: |-
      When receiving 0b10101110
      at the input.

      It will output 8 bytes
      in MSB endianness
      in the following time order:
      0b00000001,
      0b00000000,
      0b00000001,
      0b00000000,
      0b00000001,
      0b00000001,
      0b00000001,
      0b00000000.
    k: '8'
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class byte_logger(gr.sync_block):
          def __init__(self, samp_rate=32000, filename="byte_log.csv"):
              gr.sync_block.__init__(self,
                  name="BYTE FILE SINK",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.start_time = time.time()

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;byte;samp_rate\n")

          def work(self, input_items, output_items):
              current_time = time.time()
              elapsed = current_time - self.start_time

              for i, b in enumerate(input_items[0]):
                  timestamp = elapsed + (i / self.samp_rate)
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  val = str(b)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')
                  self.f.write(f"{ts};{val};{sr}\n")

              self.f.flush()
              return len(input_items[0])
    filename: '''01_byte_log.csv'''
    samp_rate: samp_rate
  states: {}
- name: epy_block_1_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class byte_logger(gr.sync_block):
          def __init__(self, samp_rate=32000, filename="byte_log.csv"):
              gr.sync_block.__init__(self,
                  name="BYTE FILE SINK",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.start_time = time.time()

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;byte;samp_rate\n")

          def work(self, input_items, output_items):
              current_time = time.time()
              elapsed = current_time - self.start_time

              for i, b in enumerate(input_items[0]):
                  timestamp = elapsed + (i / self.samp_rate)
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  val = str(b)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')
                  self.f.write(f"{ts};{val};{sr}\n")

              self.f.flush()
              return len(input_items[0])
    filename: '"02_unpack_8_bits_log.csv"'
    samp_rate: samp_rate
  states: {}
- name: epy_block_1_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class byte_logger(gr.sync_block):
          def __init__(self, samp_rate=32000, filename="byte_log.csv"):
              gr.sync_block.__init__(self,
                  name="BYTE FILE SINK",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.start_time = time.time()

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;byte;samp_rate\n")

          def work(self, input_items, output_items):
              current_time = time.time()
              elapsed = current_time - self.start_time

              for i, b in enumerate(input_items[0]):
                  timestamp = elapsed + (i / self.samp_rate)
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  val = str(b)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')
                  self.f.write(f"{ts};{val};{sr}\n")

              self.f.flush()
              return len(input_items[0])
    filename: '"03_byte_pack_8_bits_log.csv"'
    samp_rate: samp_rate
  states: {}
- name: epy_block_1_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class byte_logger(gr.sync_block):
          def __init__(self, samp_rate=32000, filename="byte_log.csv"):
              gr.sync_block.__init__(self,
                  name="BYTE FILE SINK",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.start_time = time.time()

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;byte;samp_rate\n")

          def work(self, input_items, output_items):
              current_time = time.time()
              elapsed = current_time - self.start_time

              for i, b in enumerate(input_items[0]):
                  timestamp = elapsed + (i / self.samp_rate)
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  val = str(b)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')
                  self.f.write(f"{ts};{val};{sr}\n")

              self.f.flush()
              return len(input_items[0])
    filename: '"04_repack_1_to_8_bytes_log.csv"'
    samp_rate: samp_rate
  states: {}
- name: epy_block_1_0_0_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import time
      import os

      class byte_logger(gr.sync_block):
          def __init__(self, samp_rate=32000, filename="byte_log.csv"):
              gr.sync_block.__init__(self,
                  name="BYTE FILE SINK",
                  in_sig=[np.uint8],
                  out_sig=None)
              self.filename = filename
              self.samp_rate = samp_rate
              self.start_time = time.time()

              file_exists = os.path.isfile(filename)
              self.f = open(filename, "w", encoding="utf-8")

              if not file_exists or os.stat(filename).st_size == 0:
                  self.f.write("timestamp;byte;samp_rate\n")

          def work(self, input_items, output_items):
              current_time = time.time()
              elapsed = current_time - self.start_time

              for i, b in enumerate(input_items[0]):
                  timestamp = elapsed + (i / self.samp_rate)
                  ts = f"{timestamp:.6f}".replace('.', ',')
                  val = str(b)
                  sr = f"{self.samp_rate:.0f}".replace('.', ',')
                  self.f.write(f"{ts};{val};{sr}\n")

              self.f.flush()
              return len(input_items[0])
    filename: '"05_byte_pack_8_bits_log.csv"'
    samp_rate: samp_rate
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [blocks_message_strobe_1, strobe, pdu_pdu_to_tagged_stream_0, pdus]
- [blocks_pack_k_bits_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', epy_block_1_0_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_repack_bits_bb_0, '0', epy_block_1_0_0_0_0_0, '0']
- [blocks_repack_bits_bb_0_0, '0', epy_block_1_0_0_0_0_1, '0']
- [blocks_throttle2_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_throttle2_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', epy_block_1_0_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', epy_block_1_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
